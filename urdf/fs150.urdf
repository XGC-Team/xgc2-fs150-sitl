Commit message: Remove FS150 Gazebo GPS model

File: urdf/fs150.urdf (robot description, URDF)
Before this commit: robot fs150, 7 links, 6 joints
Links:
- removed link gps0_link
Joints:
- removed joint gps0_joint
